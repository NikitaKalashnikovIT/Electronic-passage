# Keil uVision project control.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100CB STMicroelectronics
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: control +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App/User
    ./: main.c _Timers.c _Timers.h default.h AS5043.c define.h AS5043.h keyboard.c keyboard.h messages.c messages.h turnstile.c turnstile.h flash.c flash.h periphery.c periphery.h _usart.c _usart.h Command_Processor.c Command_Processor.h reader.c reader.h motor.c motor.h
  group ::Device
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: GPIO_STM32F10x.c
    RTE/Device/STM32F100CB/: RTE_Device.h startup_stm32f10x_md_vl.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.20.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
